# Keil uVision project project - 副本.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F460JETA HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, HC32F460, USE_DDL_DRIVER, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: Adp;.;applications;.;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;Dev;.;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;Dev\dev_mgr;Dev\dev_power;Dev\dev_adc;.;board;board\ports;board\config;libraries\hc32_drivers;rt-thread\components\finsh;.;rt-thread\include;libraries\hc32f460_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;libraries\hc32f460_ddl\drivers\cmsis\Include;libraries\hc32f460_ddl\drivers\hc32_ll_driver\inc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;RTT;.;Utils;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group Adp
    Adp/: hc32_drv_adc.c hc32_drv_gpio.c hc32_drv_timer.c hc32_drv_pwm.c hc32_drv_flash.c
  group Applications
    applications/: common.c main.c rtt_manager.c rtt_console.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Dev
    Dev/dev_adc/: dev_adc.c
    Dev/: dev_registry.c
    Dev/dev_param/: dev_param.c
    Dev/dev_act/: dev_act.c
    Dev/dev_monitor/: dev_monitor.c
    Dev/dev_hall_rod/: dev_hall_rod.c
    Dev/dev_hall_motor/: dev_hall_motor.c
    Dev/dev_gpio_motor/: dev_gpio_motor.c
    Dev/dev_pwm/: dev_pwm.c
    Dev/dev_rod/: dev_rod_position.c dev_rod_state.c dev_rod_calib.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
  group DevMgr
    Dev/dev_mgr/: dev_sm_thread.c dev_model.c dev_state.c
  group DevPower
    Dev/dev_power/: dev_cur_sensor.c dev_bus_voltage.c dev_power_isr.c dev_polarity.c
  group Task
    Task/: task_set.c led_task.c di_task.c rod_task.c
  group Drivers
    board/: board.c board_config.c
    libraries/hc32f460_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f460.s
    libraries/hc32_drivers/: drv_gpio.c drv_irq.c drv_spi.c drv_usart.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    libraries/hc32f460_ddl/drivers/hc32_ll_driver/src/: hc32_ll_clk.c hc32_ll_spi.c hc32_ll_icg.c hc32_ll_utility.c hc32_ll_fcg.c hc32_ll_interrupts.c hc32_ll_efm.c hc32_ll_aos.c hc32_ll_sram.c hc32_ll.c hc32_ll_usart.c hc32_ll_adc.c hc32_ll_gpio.c hc32f460_ll_interrupts_share.c hc32_ll_rmu.c hc32_ll_pwc.c hc32_ll_tmr0.c hc32_ll_tmr4.c hc32_ll_tmr6.c hc32_ll_dma.c
    libraries/hc32f460_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f460.c
  group RTT
    RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Utils
    Utils/: state_engine.c us_timer.c param_manager.c
